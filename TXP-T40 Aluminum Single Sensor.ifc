Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
Time: 2025-10-15T16:38:14-05:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 ft
Pset_ProductRequirements - Category: Project Information; sets with these values: 2

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 ft
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 ft
Dimensions - Computation Height: 0 ft
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1582
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcBuildingElementProxy: Gas-Detection_Fixed_TXP-T40_Aluminum-Housing_Macurco:Gas-Detection_Fixed_TXP-T40_Aluminum-Housing_Macurco, Gas-Detection_Fixed_TXP-T40_Aluminum-Housing_Macurco:Gas-Detection_Fixed_TXP-T40_Aluminum-Housing_Macurco:103693
In: Level 1
Type - Material: Green Surface, Black Surface, Aluminum Surface, Grey Surface, White Surface, Stainless Steel
Type - Constraints - Default Elevation: 4 ft
Type - Dimensions - Depth: 0.420898 ft; Length: 0.666667 ft; Width: 0.416667 ft
Type - Identity Data - CAD Details: https://www.arcat.com/company/macurco-inc-50560/cad; Copyright: ARCAT; Keynote: 284200; Manufacturer: Macurco; Product Page URL: https://www.arcat.com/company/macurco-inc-50560; Specification: https://www.arcat.com/company/macurco-inc-50560/spec; Type Name: Gas-Detection_Fixed_TXP-T40_Aluminum-Housing_Macurco; URL: https://macurco.com
Type - Materials and Finishes - Aluminum Surface: Aluminum Surface; Black Surface: Black Surface; Green Surface: Green Surface; Grey Surface: Grey Surface; Stainless Steel: Stainless Steel; White Surface: White Surface
Type - Other - Category: Generic Models; Family Name: Gas-Detection_Fixed_TXP-T40_Aluminum-Housing_Macurco
Type - Pset_ManufacturerTypeInformation - Manufacturer: Macurco
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_ProvisionForVoid - Width: 0.416667 ft; Depth: 0.420898 ft
Material: Black Surface, YELLOW, RED, Aluminum Surface, BUTTONS, Stainless Steel, Green Surface, Glass, White Surface, <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Gas-Detection_Fixed_TXP-T40_Aluminum-Housing_Macurco; sets with these values: 2
Constraints - Elevation from Level: 0 ft; Host: Basic Wall : Wall 1
Dimensions - Area: 0.78751 ft2; Volume: 0.0404625 ft3
Other - Family: Gas-Detection_Fixed_TXP-T40_Aluminum-Housing_Macurco; Family and Type: Gas-Detection_Fixed_TXP-T40_Aluminum-Housing_Macurco: Gas-Detection_Fixed_TXP-T40_Aluminum-Housing_Macurco; Type: Gas-Detection_Fixed_TXP-T40_Aluminum-Housing_Macurco; Type Id: 103667
Phasing - Phase Created: New Construction
